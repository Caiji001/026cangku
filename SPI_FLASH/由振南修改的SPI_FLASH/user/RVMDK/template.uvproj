# Keil uVision project template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Hardware\FLASH\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group RVMDK
    ./: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ../: main.c stm32f10x_it.c
  group Lib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_spi.c
  group Hardware
    ../../Hardware/FLASH/src/: flash.c
